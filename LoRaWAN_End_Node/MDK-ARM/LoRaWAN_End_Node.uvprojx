# Keil uVision project LoRaWAN_End_Node.uvprojx, settings and files
target LoRaWAN_End_Node (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WLE5CBUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: LoRaWAN_End_Node +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WLE5xx,LM40x=2
  c include: ../Core/Inc;../LoRaWAN/App;../LoRaWAN/Target;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Utilities/trace/adv_trace;../Utilities/misc;../Utilities/sequencer;../Utilities/timer;../Utilities/lpm/tiny_lpm;../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages;../Middlewares/Third_Party/SubGHz_Phy;../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Middlewares/Third_Party/LoRaWAN/Crypto;../Middlewares/Third_Party/LoRaWAN/Mac/Region;../Middlewares/Third_Party/LoRaWAN/Mac;../Middlewares/Third_Party/LoRaWAN/LmHandler;../Middlewares/Third_Party/LoRaWAN/Utilities;../Drivers/CMSIS/Include;../DS18B20;../BSP;../plc_frequency
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wle5xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c adc_if.c usart_if.c rtc.c subghz.c tim.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c lora_info.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/LoRaWAN
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: LmhpCompliance.c
    ../Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    ../Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    ../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio_driver.c radio_fw.c radio.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group BSP
    ../../../../../BSP/stm32wlxx-nucleo-bsp/stm32wlxx-nucleo-bsp-main/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group DS18B20
    ../DS18B20/: ds18b20.c
  group ChannelSelect
    ../plc_frequency/: channel_select.c
software components: CMSIS:CORE 5.5.0
